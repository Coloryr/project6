# Keil uVision project STM32.uvprojx, settings and files
target STM32 (ARM-ADS)
  device: STMicroelectronics
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  library: MicroLIB
  group 
    ./: 
software components: CMSIS:CORE 4.3.0
